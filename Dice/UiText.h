#pragma once
#include <LovyanGFX.hpp>
#include <stdint.h>
#include <string.h>

namespace UiText {
// Compact uppercase bitmap letters remain readable on the 240-pixel dial.
constexpr uint8_t FONT[][5]={
 {0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},
 {0x3E,0x41,0x41,0x41,0x22},{0x7F,0x41,0x41,0x22,0x1C},
 {0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},
 {0x3E,0x41,0x49,0x49,0x7A},{0x7F,0x08,0x08,0x08,0x7F},
 {0,0x41,0x7F,0x41,0},{0x20,0x40,0x41,0x3F,0x01},
 {0x7F,0x08,0x14,0x22,0x41},{0x7F,0x40,0x40,0x40,0x40},
 {0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},
 {0x3E,0x41,0x41,0x41,0x3E},{0x7F,0x09,0x09,0x09,0x06},
 {0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},
 {0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7F,0x01,0x01},
 {0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},
 {0x3F,0x40,0x38,0x40,0x3F},{0x63,0x14,0x08,0x14,0x63},
 {0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},
 {0x3E,0x51,0x49,0x45,0x3E},{0,0x42,0x7F,0x40,0},
 {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},
 {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},
 {0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
 {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},
 {0x63,0x13,0x08,0x64,0x63},{0,0,0,0,0},
 {0x08,0x14,0x22,0x41,0},{0,0x41,0x22,0x14,0x08},
 {0x08,0x08,0x08,0x08,0x08},{0,0x60,0x60,0,0}
};
inline void draw(lgfx::LGFXBase& canvas,const char* text,int centerX,int y,int scale,uint16_t color) {
  int x=centerX-(static_cast<int>(strlen(text))*6-1)*scale/2;
  for(const char* p=text;*p;++p) {
    int index=37;
    if(*p>='A' && *p<='Z') index=*p-'A';
    else if(*p>='0' && *p<='9') index=*p-'0'+26;
    else if(*p=='%') index=36;
    else if(*p=='<') index=38;
    else if(*p=='>') index=39;
    else if(*p=='-') index=40;
    else if(*p=='.') index=41;
    for(int column=0;column<5;++column) for(int row=0;row<7;++row)
      if(FONT[index][column]&(1<<row)) canvas.fillRect(x+column*scale,y+row*scale,scale,scale,color);
    x+=6*scale;
  }
}
}
